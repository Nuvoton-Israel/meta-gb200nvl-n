OBMC_IMAGE_EXTRA_INSTALL:append = " persistent-net-name"
OBMC_IMAGE_EXTRA_INSTALL:remove = " nvidia-fdr"