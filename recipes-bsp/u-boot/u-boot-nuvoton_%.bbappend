FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRCREV = "4b7dd7dd317115fa1978dc0a89ca313cfd036294"
