FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI:append = " file://create-partition.sh"

